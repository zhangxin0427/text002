# Keil uVision project Bootloader.uvprojx, settings and files
target Bootloader (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\User;..\User\bsp\inc;..\User\bsp;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\MALLOC;..\FatFs\src;..\FatFs\src\option;..\Iap
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSIS
    ../User/: system_stm32f10x.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c stm32f10x_sdio.c
    ../User/: stm32f10x_it.c
  group Bsp
    ../User/bsp/src/: bsp_beep.c bsp_flash.c bsp_led.c bsp_uart_fifo.c bsp_wdg.c bsp_sdio_sd.c bsp_sys.c bsp_dwt.c
    ../User/: bsp.c
  group User
    ../User/: main.c
  group Fatfs
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/src/option/: ccsbcs.c
  group Iap
    ../Iap/: bsp_iap.c
