# Keil uVision project FDO.uvprojx, settings and files
target DO-Y100 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FDOexpLBH +hex
  AfterMake: C:\Keil_V5\ARM\ARMCC\bin\fromelf.exe  --bin -o e:\Update\fdoexpLBH.bin ..\OBJ\fdoexpLBH.axf
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\TIMER;..\HARDWARE\24CXX;..\HARDWARE\CRC;..\HARDWARE\RTC;..\HARDWARE\SPI;..\HARDWARE\RS485;..\HARDWARE\GPRS;..\HARDWARE\ADC;..\SYSTEM\IAP;..\SYSTEM\IAP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/CRC/: crc.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/RS485/: RS485.c
    ../HARDWARE/hpi/: HPI.c
    ../HARDWARE/spi_aic/: SPI_AIC.c
    ../HARDWARE/LTC2450/: LTC2450.c
    ../HARDWARE/power_sup/: power_sup.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/IAP/: iap.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_adc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_pwr.c stm32f10x_fsmc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_sdio.c stm32f10x_wwdg.c
