# Keil uVision project DO-Y101.uvprojx, settings and files
target DO-Y101 (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fdoexpLBH +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o  ../OBJ/@L.bin  ../OBJ/@L.axf
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\HARDWARE;..\CORE;..\STM32F10x_DSP_Lib\inc;..\STM32F10x_DSP_Lib\src
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: adc.c crc.c timer.c RS485.c LTC2450.c HPI.c SPI_AIC.c power_sup.c
  group SYSTEM
    ../SYSTEM/: dac1.c delay.c iap.c sys.c usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group DSP
    ../STM32F10x_DSP_Lib/inc/: stm32_dsp.h table_fft.h
    ../STM32F10x_DSP_Lib/src/: cr4_fft_64_stm32.s cr4_fft_256_stm32.s cr4_fft_1024_stm32.s fir_stm32.s iirarma_stm32.s cr4_fft_4096_stm32.s
